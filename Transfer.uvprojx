# Keil uVision project Transfer.uvprojx, settings and files
target TransferPrj (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC085C8Q9 Linko
  pack: Linko.LKS08x.1.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Transfer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=161
  c include: .\Driver\Inc;.\System\Inc;.\LKS32MC08x_Periph_Driver\Include;.\FreeRTOS-Kernel\include;.\FreeRTOS-Kernel\portable\RVDS\ARM_CM0;.\SEGGER_RTT_V764b\RTT;.\SEGGER_RTT_V764b\Config;.\Tracealyzer\config;.\Tracealyzer\include;.\Tracealyzer\streamports\Jlink_RTT\include;.\Tracealyzer\streamports\Jlink_RTT\config;.\SystemView\config;.\SystemView\FreeRTOSV10;.\SystemView\FreeRTOSV10\Config\Cortex-M;.\SystemView\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group System
    ./System/Src/: main.c freertos.c interrupt.c hardware_init.c common.c
    ./LKS32MC08x_Periph_Driver/Source/: startup_lks32mc08x.s
  group Peripheral
    ./LKS32MC08x_Periph_Driver/Source/: lks32mc08x_can.c lks32mc08x_DMA.c lks32mc08x_exti.c lks32mc08x_gpio.c lks32mc08x_iwdg.c lks32mc08x_sys.c lks32mc08x_tim.c lks32mc08x_uart.c lks32mc08x_nvr.lib
  group Drivers
    ./Driver/Src/: tc_485.c tc_can.c tc_uart .c
  group FreeRTOS
    ./FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ./FreeRTOS-Kernel/portable/RVDS/ARM_CM0/: port.c
    ./FreeRTOS-Kernel/: list.c queue.c tasks.c timers.c
  group SystemView
    ./SystemView/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c
    ./SystemView/FreeRTOSV10/: SEGGER_SYSVIEW_FreeRTOS.c
    ./SystemView/FreeRTOSV10/Config/Cortex-M/: SEGGER_SYSVIEW_Config_FreeRTOS.c
software components: CMSIS:CORE 5.5.0
