# Keil uVision project LK_StdPeriph.uvproj, settings and files
target Linko Project (ARM-ADS)
  device: LKS32MC081 Linko
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(96000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LK_StdPeriph +hex
  c flags: Optim=1
  c include: .\FreeMaster;.\Include;.\LKS32MC08x_Periph_Driver\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source code
    ./Source/: interrupt.c main.c hardware_init.c startup_lks32mc08x.s
  group Freemaster
    ./FreeMaster/: freemaster_appcmd.c freemaster_bdm.c freemaster_can.c freemaster_Kxx.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c
  group Periph_Driver
    ./LKS32MC08x_Periph_Driver/Source/: lks32mc08x_adc.c lks32mc08x_exti.c lks32MC08x_Flash.c lks32mc08x_gpio.c lks32mc08x_hall.c lks32mc08x_MCPWM.c lks32mc08x_sys.c lks32mc08x_tim.c lks32mc08x_uart.c lks32mc08x_cmp.c lks32mc08x_spi.c lks32mc08x_i2c.c
